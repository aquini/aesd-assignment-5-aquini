## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "LDD"
	help
	  Linux Device Drivers repository for AESD assignments.
```
